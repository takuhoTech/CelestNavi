# Repository takuhoTech/CelestNavi

File README.md:

# 星導 CelestNavi-Fusion
Ready-to-use GNSS+CLAS receiver with integrated patch antenna

## KiCad design Hardware/Antenna_Module/Antenna_Module.kicad_pcb

Parts:
AE1: GPDF6010.A; Taoglas_GPDF6010.A_GNSS
C1, C2: 4.7p; C_Murata_xxx15_0402_1005Metric_1.0x0.5mm
C3: 100p; C_Murata_xxx15_0402_1005Metric_1.0x0.5mm
C4: 1000p; C_Murata_xxx15_0402_1005Metric_1.0x0.5mm
D1, D2, D3, D4, D5, D6: AXGD10402KR; D_Littelfuse_AXGD10402KR_0402_1005Metric_1.02x0.51mm
J1: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
J2: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
R1, R2: 50; R_0402_1005Metric
U1, U2: X3C14P1-03S-1; RF_HybridCoupler_TTM_X3C14P1-03S
U3: TFM.120A; Taoglas_TFM.120A_GNSS

Connections:
+3.3V: C3.1, C4.1, D5.2 (A2), J2.1, U3.20 (VIN)
GND: AE1.5 (GND), C3.2, C4.2, D1.2 (A2), D2.2 (A2), D3.1 (A1), D4.1 (A1), D5.1 (A1), D6.1 (A1), J1.2 (Ext), J2.2, R1.2, R2.2, U1.5 (GND), U2.5 (GND), U3.1 (GND), U3.3 (GND), U3.4 (GND), U3.5 (GND), U3.6 (GND), U3.7 (GND), U3.8 (GND), U3.9 (GND), U3.10 (GND), U3.11 (GND), U3.12 (GND), U3.13 (GND), U3.14 (GND), U3.15 (GND), U3.16 (GND), U3.18 (GND), U3.19 (GND), U3.21 (GND), U3.22 (GND), U3.23 (GND), U3.24 (GND), U3.25 (GND), U3.26 (GND), U3.27 (GND), U3.28 (GND), U3.29 (GND), U3.30 (GND), U3.31 (GND), U3.32 (GND), U3.33 (GND), U3.34 (GND), U3.36 (GND)
unnamed: AE1.1 (HB1), C1.1, D3.2 (A2)
unnamed: AE1.2 (HB2), C2.1, D1.1 (A1)
unnamed: AE1.3 (LB1), D4.2 (A2), U2.3 (∠θ-90)
unnamed: AE1.4 (LB2), D2.1 (A1), U2.4 (∠θ)
unnamed: D6.2 (A2), J1.1 (In), U3.17 (RF_OUT)
unnamed: U1.1 (Input), U3.2 (HB_IN)
unnamed: R1.1, U1.2 (Isolated)
unnamed: C2.2, U1.4 (∠θ)
unnamed: C1.2, U1.3 (∠θ-90)
unnamed: U2.1 (Input), U3.35 (LB_IN)
unnamed: R2.1, U2.2 (Isolated)

Notes on the sheet:
ピンの極性はPHコネクタに刺さるリポと同じ
出力マッチング回路省略
入力マッチング回路省略

Board: 2 copper layers, 80.0 x 80.0 mm, 18 parts (1 on the bottom side), 13 nets.

## KiCad design Hardware/Antenna_Module_with_integrated_receiver/Antenna_Module_with_integrated_receiver.kicad_pcb

Parts:
BT1: MS421R; Battery_Seiko_MS421R
C9, C11: 1u; C_0603_1608Metric
C10: 2.2u; C_0603_1608Metric
D1: CUHS20S30; D_Toshiba_US2H
D6: PULSE; LED_0402_1005Metric
J1: Conn_01x10; PinHeader_2x05_P1.27mm_Vertical_SMD
R4, R5, R6, R7, R9, R10: 33; R_0402_1005Metric
R8: 3.3k; R_0402_1005Metric
R11: 1k; R_0402_1005Metric
SW1: ColdStart; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
TP1: ~{SAFEBOOT_F9P}; TestPoint_Pad_D1.0mm
TP2: ~{SAFEBOOT_D9C}; TestPoint_Pad_D1.0mm
TP3: EXTINT_F9P; TestPoint_Pad_D1.0mm
TP4: EXTINT_D9C; TestPoint_Pad_D1.0mm
TP5: LNA_EN; TestPoint_Pad_D1.0mm
U7: NEO-D9C; ublox_NEO
U8: NEO-F9P; ublox_NEO

Connections:
+3.3V: C9.1, C11.1, D1.2 (A), J1.2, U7.23 (VCC), U8.23 (VCC)
+3.3VA: U7.9 (VCC_RF); also elsewhere on the board
+3.3VP: U8.9 (VCC_RF); also elsewhere on the board
+BATT: BT1.1 (+), C10.1, R8.2, U8.22 (V_BCKP)
/RF_IN_D9C: U7.11 (RF_IN); also elsewhere on the board
/RF_IN_F9P: U8.11 (RF_IN); also elsewhere on the board
/RTK: J1.10, U8.15 (RTK_STAT)
/RXD1_D9C: J1.8, U7.21 (RXD/SPI_MOSI)
/RXD1_F9P: J1.6, U8.21 (RXD/SPI_MOSI)
/SCL: J1.4, U7.19 (SCL/SPI_CLK), U8.19 (SCL/SPI_CLK)
/SDA: J1.3, R9.2, R10.1
/TP: J1.9, R11.1, U8.3 (TIMEPULSE)
/TXD1_D9C: J1.7, R7.1
/TXD1_F9P: J1.5, R6.2
/~RESET: SW1.2, U7.8 (~RESET), U8.8 (~RESET)
GND: U7.10 (GND), U7.12 (GND), U8.10 (GND), U8.12 (GND); also elsewhere on the board
GNDD: BT1.2 (-), C9.2, C10.2, C11.2, D6.1 (K), J1.1, SW1.1, U7.7 (V_USB), U7.13 (GND), U7.24 (GND), U8.7 (V_USB), U8.13 (GND), U8.24 (GND)
unnamed: D1.1 (K), R8.1
unnamed: D6.2 (A), R11.2
unnamed: TP4.1, U7.17 (EXTINT)
unnamed: R4.2, U7.4 (RXD2)
unnamed: R10.2, U7.18 (SDA/~SPI_CS)
unnamed: R5.2, U7.3 (TXD2)
unnamed: R7.2, U7.20 (TXD/SPI_MISO)
unnamed: TP2.1, U7.1 (~SAFEBOOT)
unnamed: TP3.1, U8.4 (EXTINT)
unnamed: TP5.1, U8.14 (LNA_EN)
unnamed: R5.1, U8.17 (RXD2)
unnamed: R9.1, U8.18 (SDA/~SPI_CS)
unnamed: R4.1, U8.16 (TXD2)
unnamed: R6.1, U8.20 (TXD/SPI_MISO)
unnamed: TP1.1, U8.1 (~SAFEBOOT)

Notes on the sheet:
ダンピング抵抗が必要か要らないかは、 sparkfun基板の特性Zと抵抗値から出力Zを見積もって決める 4層基板にすると同じ配線幅でも2層基板より特性Zが低くなり、ダンピング抵抗の値が小さくなる あんまり変わらん説はある
LEDは果たして必要なのか
電流制限抵抗は電圧リップルの原因になりうるかも コネクタは無いのでオミットする？ LNA電源はF9PとD9Cのどちらかから取る LNAごとに変えても良いかも LNAごとに変えるなら+3.3VADCとか使う？ 3つのLNAにLNA_ENをつなげると経路設計が大変になるので使わない
10pinに収めて2x05ピンヘッダを使うのはあり
I2C peripheral mode only
I2C+UART only
SDA,SCLを共通にすると、SPI_CSとSPI_CLKも共通になる。 ペリフェラルのCSが共通の時点でSPIはまともに使えない よってD_SELはOPENで固定
RESETはプルアップ抵抗内臓 UARTとかのIOからもコールドスタートさせられるのでRESETはコネクタに引き出さない D_SELはOPENでUART+I2C

Parts:
AE1: GPDF6010.A; Taoglas_GPDF6010.A_GNSS
C1, C2: 4.7p; C_Murata_xxx15_0402_1005Metric_1.0x0.5mm
C3, C4, C6: 1000p; C_Murata_xxx15_0402_1005Metric_1.0x0.5mm
C5: 2.4p; C_Murata_xxx15_0402_1005Metric_1.0x0.5mm
C7, C8: 1p; C_Murata_xxx15_0402_1005Metric_1.0x0.5mm
D2, D3, D4, D5: AXGD10402KR; D_Littelfuse_AXGD10402KR_0402_1005Metric_1.02x0.51mm
L1: 12nH; L_Murata_LQW15ANxxxx80x_0402_1005Metric_1.0x0.6mm
L2, L6: 20nH; L_Murata_LQW15ANxxxx80x_0402_1005Metric_1.0x0.6mm
L3: 3.3nH; L_Murata_LQW15ANxxxx80x_0402_1005Metric_1.0x0.6mm
L4: 5.6nH; L_Murata_LQW15ANxxxx80x_0402_1005Metric_1.0x0.6mm
L5: 3.6nH; L_Murata_LQW15ANxxxx80x_0402_1005Metric_1.0x0.6mm
R1, R2: 50; R_0402_1005Metric
R3: 100; R_Vishay_FC0603xxxxxxTxx_0603_1608Metric_1.626x0.813mm
U1, U2: C0727J5003AHF-1; Xinger_0805_2012Metric-6_Pad0.33x0.35mm
U3: NJG1155UX2; Nisshinbo_EPFFP-6-FA
U4, U6: NT1192FAAE1S; Nisshinbo_EPFFP-6-FA
U5: PD0922J5050S2HF; Xinger_0805_2012Metric-6_Pad0.33x0.41mm
X1: TA1985A; Filter_SAW-6_3.0x3.0mm
X2: TE0133B; Filter_SAW-8_3.0x3.0mm

Connections:
+3.3VA: C4.1, C6.1, U4.2 (VDD), U4.6 (VCTL), U6.2 (VDD), U6.6 (VCTL); also elsewhere on the board
+3.3VP: C3.1, U3.2 (VDD), U3.6 (VCTL); also elsewhere on the board
/RF_IN_D9C: U6.3 (RFOUT); also elsewhere on the board
/RF_IN_F9P: C5.1, L5.2; also elsewhere on the board
GND: AE1.5 (GND), C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D2.2 (A2), D3.1 (A1), D4.2 (A2), D5.1 (A1), R1.2, R2.2, U1.2 (GND), U1.5 (GND), U2.2 (GND), U2.5 (GND), U3.1 (GND), U3.4 (GND), U4.1 (GND), U4.4 (GND), U5.1 (GND), U5.3 (GND), U5.5 (GND), U6.1 (GND), U6.4 (GND), X1.1 (GND), X1.3 (GND), X1.4 (GND), X1.6 (GND), X2.1 (GND), X2.3 (GND), X2.4 (GND), X2.6 (GND), X2.8 (GND); also elsewhere on the board
unnamed: AE1.1 (HB1), C1.1, D3.2 (A2)
unnamed: AE1.2 (HB2), C2.1, D2.1 (A1)
unnamed: AE1.3 (LB1), D5.2 (A2), U2.6 (∠θ-90)
unnamed: AE1.4 (LB2), D4.1 (A1), U2.4 (∠θ)
unnamed: L1.1, U1.1 (Input)
unnamed: R1.1, U1.3 (Isolated)
unnamed: C2.2, U1.4 (∠θ)
unnamed: C1.2, U1.6 (∠θ-90)
unnamed: L2.1, U2.1 (Input)
unnamed: R2.1, U2.3 (Isolated)
unnamed: L1.2, U3.5 (RFIN)
unnamed: C7.1, L3.1, U3.3 (RFOUT)
unnamed: L2.2, U4.5 (RFIN)
unnamed: U4.3 (RFOUT), U5.2 (Input)
unnamed: R3.2, U5.4 (Output1), X1.2 (IN)
unnamed: C8.1, L4.1, R3.1, U5.6 (Output2)
unnamed: L6.2, U6.5 (RFIN)
unnamed: L6.1, X1.5 (OUT)
unnamed: L5.1, X2.2 (COM)
unnamed: L3.2, X2.5 (L1)
unnamed: L4.2, X2.7 (L5)

Notes on the sheet:
NJG1155の入力整合インダクタについて LQG15HSシリーズの場合は10nH LQW15Aシリーズの場合は12nHになり、雑音指数が改善する NT1192は初めからLQW15ANを想定
LNAの出力はDCカットキャパシタ入り
パワーディバイダの接続は必要に応じて逆にする ハイブリッドカプラも反転可能だが意味はない

Board: 4 copper layers, 80.0 x 80.0 mm, 53 parts (1 on the bottom side), 53 nets.

## Commit log

2024-08-18 KiCadプロジェクトを追加
2024-10-24 フロントエンド仮完成
2024-11-09 TE0149AをTE0133Bに変更
2024-12-17 回路図完成
2024-12-19 アンテナの給電点が逆になっていたのを修正
2024-12-19 アンテナのFP修正に伴う回路図の修正
2024-12-19 グリッドとドリルの原点を設定
2025-01-02 部品配置決定
2025-01-09 スタックアップを決定
2025-01-13 円弧配線に対応
2025-01-25 RFフロントエンド配線完了
2025-01-26 add GND plane
2025-03-26 レシーバ無し版の回路図完成
2025-03-27 データシート整理
2025-04-04 基板設定済み
2025-04-13 ビア配置
